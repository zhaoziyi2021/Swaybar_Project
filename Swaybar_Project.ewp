# IAR project Swaybar_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32A503xC GD GD32A503xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32A50X
  ICCARM.CCIncludePath2: $PROJ_DIR$; CANStack\APP; CANStack\CAN; CANStack\COM; CANStack\EB; CANStack\TP; CANStack\Types; CANStack\UDS; DTC; EEPROM; Encrypt; LowPower; RTE; Service; SoftTimer; Task; GD32A503_Drv\CMSIS; GD32A503_Drv\GD32A50x_standard_peripheral\Include; GD32A503_Drv; Core_include; ERROR_interrupt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Swaybar_Project.hex
  ILINK.IlinkOutputFile: Swaybar_Project.out
  ILINK.IlinkIcfFile: GD32A503VC_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MAIN.c Swaybar.c
  group CANStack/APP
    CANStack/APP/: APP_Cbk.h APP_Prg.c APP_Pub.h APP_Types.h
  group CANStack/CAN
    CANStack/CAN/: CAN_Cbk.h CAN_Cfg.c CAN_Cfg.h CAN_Hw.h CAN_Irq.c CAN_Prg.c CAN_Pub.h CAN_Trcv.c CAN_Types.h
  group CANStack/COM
    CANStack/COM/: COM_Cbk.h COM_Cfg.c COM_Cfg.h COM_Prg.c COM_Pub.h COM_Types.h IL_Cbk.h IL_Cfg.h IL_Prg.c IL_Pub.h IL_Types.h
  group CANStack/EB
    CANStack/EB/: EB_Cbk.h EB_Cfg.c EB_Cfg.h EB_Prg.c EB_Prj.h EB_Pub.h EB_Types.h
  group CANStack/TP
    CANStack/TP/: TP_Cbk.h TP_Cfg.c TP_Cfg.h TP_Prg.c TP_Pub.h TP_Types.h
  group CANStack/Types
    CANStack/Types/: ncs.h ncs_cbk.h ncs_limits.h ncs_macro.h ncs_sdf.h ncs_types.h
  group CANStack/UDS
    CANStack/UDS/: UDS_Cbk.h UDS_Cfg.c UDS_Cfg.h UDS_Prg.c UDS_Pub.h UDS_Types.h
  group DTC
    DTC/: DTC.c DTC.h
  group EEPROM
    EEPROM/: eepromapi.c eepromapi.h
  group Encrypt
    Encrypt/: EncryptAlg1.c EncryptAlg1.h
  group ERROR_interrupt
    ERROR_interrupt/: gd32a50x_it.c
  group GD32A503_Drv
    GD32A503_Drv/: CAN.c CANBusOff.c IO.c
  group GD32A503_Drv/CMSIS
    GD32A503_Drv/CMSIS/: startup_gd32a50x.s system_gd32a50x.c
  group GD32A503_Drv/GD32A50x_standard_peripheral
    GD32A503_Drv/GD32A50x_standard_peripheral/Source/: gd32a50x_adc.c gd32a50x_bkp.c gd32a50x_can.c gd32a50x_cmp.c gd32a50x_crc.c gd32a50x_dac.c gd32a50x_dbg.c gd32a50x_dma.c gd32a50x_exti.c gd32a50x_fmc.c gd32a50x_fwdgt.c gd32a50x_gpio.c gd32a50x_i2c.c gd32a50x_mfcom.c gd32a50x_misc.c gd32a50x_pmu.c gd32a50x_rcu.c gd32a50x_rtc.c gd32a50x_spi.c gd32a50x_syscfg.c gd32a50x_timer.c gd32a50x_trigsel.c gd32a50x_usart.c gd32a50x_wwdgt.c
  group LowPower
    LowPower/: LowPowerApi.c LowPowerApi.h
  group RTE
    RTE/: RTE.c RTE.h
  group Service
    Service/: Service.h Srv_Com.c Srv_IO.c
  group SoftTimer
    SoftTimer/: SoftTimerAppExt.h SoftTimerCfgExt.h SoftTimerDrv.c SoftTimerDrv.h
  group Task
    Task/: TaskStep.c TaskStep.h
